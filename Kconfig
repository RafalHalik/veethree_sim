## Kconfig
```kconfig
#
# Copyright (c) 2020 Linumiz
#
# SPDX-License-Identifier: Apache-2.0
#


config VE_SIM
	bool 



#
#
```
